CMDLINE_ROOTFS:append = " console=serial0,115200 console=tty1 fsck.repair=yes plymouth.ignore-serial-consoles fbcon=scrollback:1024k"
